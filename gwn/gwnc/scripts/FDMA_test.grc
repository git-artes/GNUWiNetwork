<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>ARTES</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>deframer80211</key>
<param><key>id</key><value>deframer80211_0</value></param>
</block>
<block>
<key>timer</key>
<param><key>id</key><value>timer_0</value></param>
<param><key>interval</key><value>5</value></param>
<param><key>retry</key><value>3</value></param>
<param><key>nickname1</key><value>TimerTimer</value></param>
</block>
<block>
<key>virtualchannel</key>
<param><key>id</key><value>virtualchannel_0</value></param>
<param><key>frame_loss</key><value>0.01</value></param>
</block>
<block>
<key>framer80211</key>
<param><key>id</key><value>framer80211_0</value></param>
</block>
<block>
<key>eventconsumer</key>
<param><key>id</key><value>eventconsumer_0</value></param>
<param><key>nickname1</key><value>Consumer Node 1</value></param>
<param><key>itype</key><value>Event</value></param>
</block>
<block>
<key>eventsim</key>
<param><key>id</key><value>eventsim_0</value></param>
<param><key>nick</key><value>DataData</value></param>
<param><key>param1</key><value>100</value></param>
<param><key>param2</key><value>101</value></param>
<param><key>param3</key><value>10</value></param>
<param><key>itype</key><value>Timer</value></param>
<param><key>otype</key><value>Event</value></param>
</block>
<block>
<key>simplefdma</key>
<param><key>id</key><value>simplefdma_0_0</value></param>
<param><key>bandDL1</key><value>851000000.0</value></param>
<param><key>bandUL1</key><value>850000000.0</value></param>
</block>
<block>
<key>deframer80211</key>
<param><key>id</key><value>deframer80211_0_0</value></param>
</block>
<block>
<key>framer80211</key>
<param><key>id</key><value>framer80211_0_0</value></param>
</block>
<block>
<key>eventconsumer</key>
<param><key>id</key><value>eventconsumer_0_0</value></param>
<param><key>nickname1</key><value>Consumer Node 2</value></param>
<param><key>itype</key><value>Event</value></param>
</block>
<block>
<key>timer</key>
<param><key>id</key><value>timer_0_0</value></param>
<param><key>interval</key><value>7</value></param>
<param><key>retry</key><value>3</value></param>
<param><key>nickname1</key><value>TimerTimer</value></param>
</block>
<block>
<key>simplefdma</key>
<param><key>id</key><value>simplefdma_0</value></param>
<param><key>bandDL1</key><value>851000000.0</value></param>
<param><key>bandUL1</key><value>850000000.0</value></param>
</block>
<block>
<key>eventsim</key>
<param><key>id</key><value>eventsim_0_0</value></param>
<param><key>nick</key><value>DataData</value></param>
<param><key>param1</key><value>101</value></param>
<param><key>param2</key><value>100</value></param>
<param><key>param3</key><value>10</value></param>
<param><key>itype</key><value>Timer</value></param>
<param><key>otype</key><value>Event</value></param>
</block>
<connection><source_block_id>deframer80211_0</source_block_id><sink_block_id>simplefdma_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtualchannel_0</source_block_id><sink_block_id>deframer80211_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>framer80211_0</source_block_id><sink_block_id>virtualchannel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>simplefdma_0</source_block_id><sink_block_id>framer80211_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>timer_0</source_block_id><sink_block_id>eventsim_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>eventsim_0</source_block_id><sink_block_id>simplefdma_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>simplefdma_0</source_block_id><sink_block_id>eventconsumer_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>deframer80211_0_0</source_block_id><sink_block_id>simplefdma_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>simplefdma_0_0</source_block_id><sink_block_id>framer80211_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>timer_0_0</source_block_id><sink_block_id>eventsim_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>eventsim_0_0</source_block_id><sink_block_id>simplefdma_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>simplefdma_0_0</source_block_id><sink_block_id>eventconsumer_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>framer80211_0_0</source_block_id><sink_block_id>virtualchannel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtualchannel_0</source_block_id><sink_block_id>deframer80211_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
