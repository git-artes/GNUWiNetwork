<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>ARTES</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>eventconsumer</key>
<param><key>id</key><value>eventconsumer_0</value></param>
<param><key>blkname</key><value>blkname</value></param>
<param><key>itype</key><value>Event</value></param>
</block>
<block>
<key>virtualchannel</key>
<param><key>id</key><value>virtualchannel_0</value></param>
<param><key>frame_loss</key><value>0.01</value></param>
</block>
<block>
<key>eventconsumer</key>
<param><key>id</key><value>eventconsumer_2</value></param>
<param><key>blkname</key><value>blkname</value></param>
<param><key>itype</key><value>Event</value></param>
</block>
<block>
<key>eventconsumer</key>
<param><key>id</key><value>eventconsumer_1</value></param>
<param><key>blkname</key><value>blkname</value></param>
<param><key>itype</key><value>Event</value></param>
</block>
<block>
<key>IEEE80211</key>
<param><key>id</key><value>IEEE80211_2</value></param>
<param><key>nodeid</key><value>0001</value></param>
</block>
<block>
<key>IEEE80211</key>
<param><key>id</key><value>IEEE80211_0</value></param>
<param><key>nodeid</key><value>0002</value></param>
</block>
<block>
<key>IEEE80211</key>
<param><key>id</key><value>IEEE80211_1</value></param>
<param><key>nodeid</key><value>0003</value></param>
</block>
<block>
<key>eventsim</key>
<param><key>id</key><value>eventsim_1</value></param>
<param><key>nick</key><value>DataData</value></param>
<param><key>interval</key><value>5</value></param>
<param><key>retry</key><value>1</value></param>
<param><key>param1</key><value>0002</value></param>
<param><key>param2</key><value>0003</value></param>
<param><key>param3</key><value>10</value></param>
<param><key>otype</key><value>Event</value></param>
</block>
<block>
<key>eventsim</key>
<param><key>id</key><value>eventsim_2</value></param>
<param><key>nick</key><value>DataData</value></param>
<param><key>interval</key><value>3</value></param>
<param><key>retry</key><value>1</value></param>
<param><key>param1</key><value>0003</value></param>
<param><key>param2</key><value>0001</value></param>
<param><key>param3</key><value></value></param>
<param><key>otype</key><value>Event</value></param>
</block>
<block>
<key>eventsim</key>
<param><key>id</key><value>eventsim_0</value></param>
<param><key>nick</key><value>DataData</value></param>
<param><key>interval</key><value>10</value></param>
<param><key>retry</key><value>5</value></param>
<param><key>param1</key><value>0001</value></param>
<param><key>param2</key><value>0002</value></param>
<param><key>param3</key><value>10000</value></param>
<param><key>otype</key><value>Event</value></param>
</block>
<connection><source_block_id>eventsim_1</source_block_id><sink_block_id>IEEE80211_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>IEEE80211_1</source_block_id><sink_block_id>eventconsumer_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>IEEE80211_0</source_block_id><sink_block_id>virtualchannel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>IEEE80211_1</source_block_id><sink_block_id>virtualchannel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>IEEE80211_2</source_block_id><sink_block_id>virtualchannel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>eventsim_0</source_block_id><sink_block_id>IEEE80211_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtualchannel_0</source_block_id><sink_block_id>IEEE80211_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtualchannel_0</source_block_id><sink_block_id>IEEE80211_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtualchannel_0</source_block_id><sink_block_id>IEEE80211_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>IEEE80211_2</source_block_id><sink_block_id>eventconsumer_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>IEEE80211_0</source_block_id><sink_block_id>eventconsumer_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>eventsim_2</source_block_id><sink_block_id>IEEE80211_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
