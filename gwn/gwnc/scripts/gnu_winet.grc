<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_0</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>parametro1</value></param>
<param><key>label</key><value>parametro1</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>timer</key>
<param><key>id</key><value>timer_0</value></param>
<param><key>interval</key><value>5</value></param>
<param><key>retry</key><value>4</value></param>
<param><key>nickname1</key><value>nickname1</value></param>
</block>
<block>
<key>eventconsumer</key>
<param><key>id</key><value>eventconsumer_0</value></param>
<param><key>nickname1</key><value>nickname1</value></param>
</block>
<connection><source_block_id>timer_0</source_block_id><sink_block_id>eventconsumer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
