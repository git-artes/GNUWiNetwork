<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>eventconsumer</key>
<param><key>id</key><value>eventconsumer_0</value></param>
<param><key>blkname</key><value>blkname</value></param>
<param><key>itype</key><value>Event</value></param>
</block>
<block>
<key>timer</key>
<param><key>id</key><value>timer_0</value></param>
<param><key>interval</key><value>variable_0</value></param>
<param><key>retry</key><value>2</value></param>
<param><key>nickname1</key><value>TimerTOR1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_0</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>parametro1</value></param>
<param><key>label</key><value>parametro1</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>eventsim</key>
<param><key>id</key><value>eventsim_0</value></param>
<param><key>nick</key><value>TimerConfig</value></param>
<param><key>interval</key><value>1</value></param>
<param><key>retry</key><value>1</value></param>
<param><key>param1</key><value>3</value></param>
<param><key>param2</key><value>1</value></param>
<param><key>param3</key><value>TimerTimer</value></param>
<param><key>otype</key><value>Event</value></param>
</block>
<block>
<key>eventconsumer</key>
<param><key>id</key><value>eventconsumer_1</value></param>
<param><key>blkname</key><value>blkname</value></param>
<param><key>itype</key><value>Event</value></param>
</block>
<connection><source_block_id>timer_0</source_block_id><sink_block_id>eventconsumer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>eventsim_0</source_block_id><sink_block_id>timer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>timer_0</source_block_id><sink_block_id>eventconsumer_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
