<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block1</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>queues_size</value></param>
<param><key>label</key><value>queues_size</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>var_0</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>eventconsumer</key>
<param><key>id</key><value>eventconsumer_0</value></param>
<param><key>blkname</key><value>blkname</value></param>
<param><key>itype</key><value>Event</value></param>
</block>
<block>
<key>framer80211</key>
<param><key>id</key><value>framer80211_0</value></param>
</block>
<block>
<key>deframer80211</key>
<param><key>id</key><value>deframer80211_0</value></param>
</block>
<block>
<key>psk</key>
<param><key>id</key><value>psk_0</value></param>
<param><key>version</key><value>6</value></param>
<param><key>args</key><value>serial=E0R11Y0B1</value></param>
<param><key>antenna</key><value>'TX/RX'</value></param>
<param><key>spec</key><value>A:0</value></param>
<param><key>rx_freq</key><value>850000000.0</value></param>
<param><key>rx_gain</key><value>15</value></param>
<param><key>tx_gain</key><value>15</value></param>
<param><key>tx_freq</key><value>851000000.0</value></param>
<param><key>tx_amplitude</key><value>0.25</value></param>
<param><key>bitrate</key><value>100000</value></param>
<param><key>sps</key><value>2</value></param>
<param><key>modulation</key><value>bpsk</value></param>
</block>
<block>
<key>eventsim</key>
<param><key>id</key><value>eventsim_0</value></param>
<param><key>nick</key><value>DataData</value></param>
<param><key>interval</key><value>1</value></param>
<param><key>retry</key><value>50</value></param>
<param><key>param1</key><value>0001</value></param>
<param><key>param2</key><value>0002</value></param>
<param><key>param3</key><value>10</value></param>
<param><key>otype</key><value>Event</value></param>
</block>
<connection><source_block_id>eventsim_0</source_block_id><sink_block_id>framer80211_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>deframer80211_0</source_block_id><sink_block_id>eventconsumer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>framer80211_0</source_block_id><sink_block_id>psk_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>psk_0</source_block_id><sink_block_id>deframer80211_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
