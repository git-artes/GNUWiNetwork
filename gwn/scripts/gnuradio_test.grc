<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block1</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>tun_tap</key>
<param><key>id</key><value>tun_tap_0</value></param>
<param><key>device</key><value>"/dev/net/tun"</value></param>
<param><key>myaddr</key><value></value></param>
<param><key>dstaddr</key><value></value></param>
</block>
<block>
<key>simplefdma</key>
<param><key>id</key><value>simplefdma_0</value></param>
<param><key>dlband1</key><value>851000000.0</value></param>
<param><key>ulband1</key><value>850000000.0</value></param>
</block>
<block>
<key>framer80211</key>
<param><key>id</key><value>framer80211_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>queues_size</value></param>
<param><key>label</key><value>queues_size</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>var_0</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>deframer80211</key>
<param><key>id</key><value>deframer80211_0</value></param>
</block>
<block>
<key>gnuradio_psk</key>
<param><key>id</key><value>gnuradio_psk_0</value></param>
<param><key>version</key><value>6</value></param>
<param><key>args</key><value>serial=E0R11Y0B1</value></param>
<param><key>antenna</key><value>'TX/RX'</value></param>
<param><key>spec</key><value>A:0</value></param>
<param><key>rx_freq</key><value>850000000.0</value></param>
<param><key>rx_gain</key><value>15</value></param>
<param><key>tx_gain</key><value>15</value></param>
<param><key>tx_freq</key><value>851000000.0</value></param>
<param><key>tx_amplityde</key><value>0.25</value></param>
<param><key>bitrate</key><value>100000</value></param>
<param><key>sps</key><value>2</value></param>
<param><key>modulation</key><value>bpsk</value></param>
</block>
<connection><source_block_id>simplefdma_0</source_block_id><sink_block_id>framer80211_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>framer80211_0</source_block_id><sink_block_id>gnuradio_psk_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gnuradio_psk_0</source_block_id><sink_block_id>deframer80211_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>deframer80211_0</source_block_id><sink_block_id>simplefdma_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>simplefdma_0</source_block_id><sink_block_id>tun_tap_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tun_tap_0</source_block_id><sink_block_id>simplefdma_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
