<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>ARTES</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>tun_tap</key>
<param><key>id</key><value>tun_tap_0</value></param>
<param><key>device</key><value>"/dev/net/tun"</value></param>
<param><key>myaddr</key><value>10:10:10:10:10:10</value></param>
<param><key>dstaddr</key><value>11:11:11:11:11:11</value></param>
</block>
<block>
<key>eventconsumer</key>
<param><key>id</key><value>eventconsumer_0</value></param>
<param><key>blkname</key><value>blkname</value></param>
<param><key>itype</key><value>Event</value></param>
</block>
<block>
<key>eventsim</key>
<param><key>id</key><value>eventsim_0</value></param>
<param><key>nick</key><value>DataData</value></param>
<param><key>interval</key><value>1</value></param>
<param><key>retry</key><value>5</value></param>
<param><key>param1</key><value>1010101</value></param>
<param><key>param2</key><value>101010</value></param>
<param><key>param3</key><value>10</value></param>
<param><key>otype</key><value>Event</value></param>
</block>
<connection><source_block_id>eventsim_0</source_block_id><sink_block_id>tun_tap_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tun_tap_0</source_block_id><sink_block_id>eventconsumer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
